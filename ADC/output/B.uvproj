# Keil uVision project B.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: B +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main files
    ../program/: main.c
  group Source files
    ../program/: lcd1602.c adc.c delay.c nrf.c
